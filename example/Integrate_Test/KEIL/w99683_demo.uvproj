# Keil uVision project w99683_demo.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w99683_demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\KEIL;..\vpost;..\..\Integrate_Test;..\LIBPNG;..\ZLIB;..\LIBPNG\sys
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: D:\projects\myProjects\N32905\N32905.sct
  link misc: --entry 0
  group Source Group 1
    ../: main.c standalone.c usb_keyboard.c W99683.c wb_init.s jpegcodec.c
    ../../../lib/: W55FA93_usbh.lib w55fa93_SPI.lib
    ../../../../SYSLIB/Lib/: W55FA93_syslib.lib
    ../../../../NVTFAT/lib/: W55FA93_nvtfat.lib
  group vpost
    ../vpost/: W55FA93_VPOST.C W55FA93_VPOST_Driver.c W55FA93_VPOST_HANNSTAR_HSD043I9W1.c
  group libpng
    ../LIBPNG/: png.c pngerror.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
  group zlib
    ../ZLIB/: adler32.c compress.c crc32.c deflate.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
